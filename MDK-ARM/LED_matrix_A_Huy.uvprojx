# Keil uVision project LED_matrix_A_Huy.uvprojx, settings and files
target LED_matrix_A_Huy (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F070C6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x200017FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: LED_matrix_A_Huy +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F070x6
  c misc: --C99
  c include: ../Inc;   ../Drivers/STM32F0xx_HAL_Driver/Inc;   ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;   ../Drivers/CMSIS/Include;   ..\Library_of_me
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f070x6.s
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_uart.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_i2c.c stm32f0xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Application/User
    ../Src/: main.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Lipbrary_of_me
    ../Library_of_me/: matrix_p3.c my_printf.c
software components: CMSIS:CORE 4.1.0
